## boards/shields/elpi_one_v1/Kconfig.defconfig
```kconfig
if SHIELD_ELPI_ONE_V1

config ZMK_KEYBOARD_NAME
    default "elpi_one_v1"

endif
```
